# Keil uVision project LCD.uvprojx, settings and files
target OLED (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08010000,0x70000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RedPic1_APP1 +hex
  AfterMake: F:\keil5\ARM\ARMCC\bin\fromelf.exe --bin -o  E:\26512VSS\source\repos\IAP\IAPWinForms_phase3\ota-release\keys\LCD_app1.bin  ..\OBJ\RedPic1_APP1.axf
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,ARM_MATH_CM4,__CC_ARM,__FPU_PRESENT=1,INCLUDE_uxTaskGetStackHighWaterMark=1
  c include: ..\USER;..\..\stm32F405RGT6-RedPic1-APP-common\APP\core;..\..\stm32F405RGT6-RedPic1-APP-common\APP\service_bus;..\..\stm32F405RGT6-RedPic1-APP-common\CORE;..\..\stm32F405RGT6-RedPic1-APP-common\SYSTEM\delay;..\..\stm32F405RGT6-RedPic1-APP-common\SYSTEM\sys;..\..\stm32F405RGT6-RedPic1-APP-common\SYSTEM\usart;..\..\stm32F405RGT6-RedPic1-APP-common\USER;..\..\stm32F405RGT6-RedPic1-APP-common\DRIVERS\board;..\..\stm32F405RGT6-RedPic1-APP-common\FWLIB\inc;..\..\stm32F405RGT6-RedPic1-APP-common\DSP_LIB\include;..\..\stm32F405RGT6-RedPic1-APP-common\DRIVERS\input;..\..\stm32F405RGT6-RedPic1-APP-common\DRIVERS\display;..\..\stm32F405RGT6-RedPic1-APP-common\DRIVERS\mlx90640;..\..\stm32F405RGT6-RedPic1-APP-common\FEATURES\ota;..\..\stm32F405RGT6-RedPic1-APP-common\FEATURES\watchdog;..\..\protocol;..\..\stm32F405RGT6-RedPic1-APP-common\DRIVERS\battery;..\..\stm32F405RGT6-RedPic1-APP-common\FEATURES\diagnostics;..\..\stm32F405RGT6-RedPic1-APP-common\FEATURES\thermal;..\..\stm32F405RGT6-RedPic1-APP-common\FEATURES\ui;..\..\stm32F405RGT6-RedPic1-APP-common\FEATURES\esp_host;..\..\stm32F405RGT6-RedPic1-APP-common\FEATURES\power;..\..\stm32F405RGT6-RedPic1-APP-common\FEATURES\settings;..\..\stm32F405RGT6-RedPic1-APP-common\FEATURES\storage;..\..\stm32F405RGT6-RedPic1-APP-common\FEATURES\snapshot;..\..\stm32F405RGT6-RedPic1-APP-common\DRIVERS\SDIO;..\..\stm32F405RGT6-RedPic1-APP-common\FATFS\src;..\..\stm32F405RGT6-RedPic1-APP-common\MALLOC;..\..\stm32F405RGT6-RedPic1-APP-common\FreeRTOS\include;..\..\stm32F405RGT6-RedPic1-APP-common\FreeRTOS\portable\RVDS\ARM_CM4F
  memory RVCT4: ROM 0x8010000 size 0x70000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\app_slot.sct
  group project/entry
    ./: main.c
  group platform/core
    ../../stm32F405RGT6-RedPic1-APP-common/USER/: stm32f4xx_it.c system_stm32f4xx.c
    ../../stm32F405RGT6-RedPic1-APP-common/CORE/: startup_stm32f40_41xxx.s
  group platform/system
    ../../stm32F405RGT6-RedPic1-APP-common/SYSTEM/delay/: delay.c
    ../../stm32F405RGT6-RedPic1-APP-common/SYSTEM/sys/: sys.c
    ../../stm32F405RGT6-RedPic1-APP-common/SYSTEM/usart/: usart.c uart_rx_ring.c
  group app/core
    ../../stm32F405RGT6-RedPic1-APP-common/APP/core/: redpic1_app.c app_shell.c
  group app/service_bus
    ../../stm32F405RGT6-RedPic1-APP-common/APP/service_bus/: app_service_bus.c
  group features/diagnostics
    ../../stm32F405RGT6-RedPic1-APP-common/FEATURES/diagnostics/: app_perf_baseline.c
  group features/thermal
    ../../stm32F405RGT6-RedPic1-APP-common/FEATURES/thermal/: redpic1_thermal.c thermal_pair.c thermal_frame_slot.c thermal_visual.c thermal_cloud.c thermal_capture.c
  group features/ui
    ../../stm32F405RGT6-RedPic1-APP-common/FEATURES/ui/: app_display_runtime.c ui_manager.c ui_renderer.c page_registry.c
  group features/esp_host
    ../../stm32F405RGT6-RedPic1-APP-common/FEATURES/esp_host/: esp_host_service.c esp_sync_service.c
  group features/power
    ../../stm32F405RGT6-RedPic1-APP-common/FEATURES/power/: power_manager.c rtc_lp_service.c clock_profile_service.c low_power_runtime.c app_pm_registry.c
  group features/watchdog
    ../../stm32F405RGT6-RedPic1-APP-common/FEATURES/watchdog/: iwdg.c watchdog_service.c watchdog_supervisor.c
  group features/ota
    ../../stm32F405RGT6-RedPic1-APP-common/FEATURES/ota/: iap.c common.c flash_if.c ota_service.c ota_menu.c
  group features/settings
    ../../stm32F405RGT6-RedPic1-APP-common/FEATURES/settings/: settings_service.c
  group features/storage
    ../../stm32F405RGT6-RedPic1-APP-common/FEATURES/storage/: storage_service.c
  group features/snapshot
    ../../stm32F405RGT6-RedPic1-APP-common/FEATURES/snapshot/: thermal_snapshot_file.c snapshot_storage.c
  group drivers/display
    ../../stm32F405RGT6-RedPic1-APP-common/DRIVERS/display/: lcd.c lcd_init.c lcd_dma.c
  group drivers/sdcard
    ../../stm32F405RGT6-RedPic1-APP-common/FEATURES/storage/: sd_card_port_stub.c
  group drivers/mlx90640
    ../../stm32F405RGT6-RedPic1-APP-common/DRIVERS/mlx90640/: MLX90640.c MLX90640_API.c MLX90640_I2C_Driver.c
  group drivers/input
    ../../stm32F405RGT6-RedPic1-APP-common/DRIVERS/input/: key.c exti_key.c
  group drivers/battery
    ../../stm32F405RGT6-RedPic1-APP-common/DRIVERS/battery/: adc.c battery_monitor.c
  group drivers/board
    ../../stm32F405RGT6-RedPic1-APP-common/DRIVERS/board/: led.c gpio_pm_service.c
  group middleware/freertos
    ../../stm32F405RGT6-RedPic1-APP-common/FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../stm32F405RGT6-RedPic1-APP-common/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../../stm32F405RGT6-RedPic1-APP-common/FreeRTOS/portable/MemMang/: heap_4.c
  group middleware/fwlib
    ../../stm32F405RGT6-RedPic1-APP-common/FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_syscfg.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_wwdg.c
  group middleware/dsp
    ../../stm32F405RGT6-RedPic1-APP-common/DSP_LIB/Source/MatrixFunctions/: arm_mat_trans_f32.c
  group middleware/fatfs
    ../../stm32F405RGT6-RedPic1-APP-common/FATFS/src/: ff.c diskio.c
